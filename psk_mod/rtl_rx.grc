<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>const</value></param>
<param><key>type</key><value>bpsk</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>eq_gain</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>label</key><value>Equalizer: rate</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>0.1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fadj</value></param>
<param><key>value</key><value>-200000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-300000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>300000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ftune</value></param>
<param><key>value</key><value>915e6</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>100e6</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lpfilter</value></param>
<param><key>value</key><value>3000</value></param>
<param><key>label</key><value>lpfilter</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>100</value></param>
<param><key>stop</key><value>50000</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_bw</value></param>
<param><key>value</key><value>6.28/100.0</value></param>
<param><key>label</key><value>Phase: Bandwidth</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>60</value></param>
<param><key>label</key><value>rf_gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps/10), 0.35, 11*sps*nfilts/10)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>timing_loop_bw</value></param>
<param><key>value</key><value>6.28/100.0</value></param>
<param><key>label</key><value>Time: BW</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>0.2</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
</block>
<block>
<key>digital_cma_equalizer_cc</key>
<param><key>id</key><value>digital_cma_equalizer_cc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>mu</key><value>eq_gain</value></param>
<param><key>modulus</key><value>1</value></param>
<param><key>num_taps</key><value>15</value></param>
<param><key>sps</key><value>20</value></param>
</block>
<block>
<key>digital_constellation_receiver_cb</key>
<param><key>id</key><value>digital_constellation_receiver_cb_0</value></param>
<param><key>constellation</key><value>const</value></param>
<param><key>loop_bw</key><value>phase_bw</value></param>
<param><key>fmax</key><value>100000</value></param>
<param><key>fmin</key><value>-100000</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>digital_descrambler_bb</key>
<param><key>id</key><value>digital_descrambler_bb_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>len</key><value>7</value></param>
<param><key>mask</key><value>0x8A</value></param>
<param><key>seed</key><value>0x7F</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>timing_loop_bw</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>2</value></param>
<param><key>sps</key><value>20</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>fadj</value></param>
<param><key>decim</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, lpfilter, 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>error</value></param>
<param><key>label2</key><value>phase</value></param>
<param><key>label3</key><value>freq</value></param>
<param><key>name</key><value>error phase freq</value></param>
<param><key>nconnections</key><value>3</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/100</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>Base band</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate/sps</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>dc_offset_mode0</key><value>1</value></param>
<param><key>freq0</key><value>ftune</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_receiver_cb_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_descrambler_bb_0</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>digital_descrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_constellation_receiver_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>3</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
